options:
  parameters:
    generate_options: qt_gui
    id: usrp_revc
    output_language: python
    title: USRP SDR Reciever
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e7
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: freq_center
    fftsize: '1024'
    name: '"USRP Check"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq_center
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
