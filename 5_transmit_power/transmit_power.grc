options:
  parameters:
    generate_options: qt_gui
    id: transmit_power
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: dev_exp
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dev_mantissa
  id: variable
  parameters:
    value: '7'
  states: {}
- name: f_center_Hz
  id: variable
  parameters:
    value: 433e6 + 0.2e6*11
  states: {}
- name: f_xosc_Hz
  id: variable
  parameters:
    value: 26e6
  states: {}
- name: freq_offset
  id: variable_qtgui_dial_control
  parameters:
    maximum: '1000'
    minimum: '-1000'
    showvalue: 'False'
    type: int
    value: '0'
  states: {}
- name: fsk_deviation_Hz
  id: variable
  parameters:
    value: (f_xosc_Hz / 2**17) * (8 + dev_mantissa) * 2**dev_exp
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: f_center_Hz
    fftsize: '1024'
    name: '"Passband"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: f_center_Hz
    fftsize: '1024'
    name: '"Passband"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*50
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: 2048*80
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: f_center_Hz+freq_offset
    gain0: gain_db
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
