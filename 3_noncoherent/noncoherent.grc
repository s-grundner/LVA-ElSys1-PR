options:
  parameters:
    generate_options: qt_gui
    id: usrp_send
    output_language: python
    title: Non Coherent FSK Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: dev_exp
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dev_mantissa
  id: variable
  parameters:
    value: '7'
  states: {}
- name: f_center_Hz
  id: variable
  parameters:
    value: 433.2e6
  states: {}
- name: f_xosc_Hz
  id: variable
  parameters:
    value: 26e6
  states: {}
- name: fsk_deviation_Hz
  id: variable
  parameters:
    value: (f_xosc_Hz / 2**17) * (8 + dev_mantissa) * 2**dev_exp
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 18000+5e3
    low_cutoff_freq: 18000-5e3
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-fsk_deviation_Hz/2+5e3'
    low_cutoff_freq: '-fsk_deviation_Hz/2-5e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/simon/Dokumente/repos-jku/ElSys-PR/2_usrp_send/4-fsk-b3.gnc
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 1024*20
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: 2048*80
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: 2048*50
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: 2048*50
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    type: fff
  states: {state: bypassed}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: f_center_Hz
    gain0: gain_db
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [band_pass_filter_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
