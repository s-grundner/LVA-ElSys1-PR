options:
  parameters:
    generate_options: qt_gui
    id: usrp_revc
    output_language: python
    title: USRP SDR Reciever
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: dev_exp
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dev_mantissa
  id: variable
  parameters:
    value: '7'
  states: {}
- name: f_center_Hz
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: f_xosc_Hz
  id: variable
  parameters:
    value: 26e6
  states: {}
- name: fsk_deviation_Hz
  id: variable
  parameters:
    value: (f_xosc_Hz / 2**17) * (8 + dev_mantissa) * 2**dev_exp
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_Hz)
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: '0'
    fftsize: '1024'
    name: '"Baseband"'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: f_center_Hz
    fftsize: '1024'
    name: '"Passband"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: f_center_Hz
    gain0: gain_db
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
